TYPE ST_CSVDataStruct :
STRUCT
	ID: LINT;
	Timestamp: DT;
	Name: STRING(80);
	Velocity: LREAL;
	Temperature: LREAL;
END_STRUCT
END_TYPE
