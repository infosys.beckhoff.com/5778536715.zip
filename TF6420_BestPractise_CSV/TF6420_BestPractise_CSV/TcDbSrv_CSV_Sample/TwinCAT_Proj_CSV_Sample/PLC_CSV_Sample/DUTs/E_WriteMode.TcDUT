{attribute 'qualified_only'}
{attribute 'strict'}
TYPE E_WriteMode :
(
	ePLCDBCmd   := 0,
	ePLCDBWriteStruct	:= 1,
	ePLCDBReadStruct 	:= 2
	
);
END_TYPE
